# Keil uVision project Main.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F103CB Geehy
  pack: Geehy.APM32F1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Main +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APM32F103xB
  c include: .;.\SYSTEM\sys;.\SYSTEM\usart;.\SYSTEM\delay;.\Src\JY61P;.\Src\LED;.\Src\Buzzer;.\Src\Motor;.\Src\Posture;.\Libraries\APM32F10x_StdPeriphDriver\inc;.\Libraries\CMSIS\Core\Include;.\Libraries\Device\Geehy\APM32F10x\Include;.\SYSTEM\usart2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c
  group Src
    ./Src/JY61P/: jy61p.c
    ./Src/LED/: indicator_led.c
    ./Src/Buzzer/: buzzer.c
    ./Src/Motor/: vibrator.c
    ./Src/Posture/: posture_detect.c
  group Sys
    ./SYSTEM/usart/: usart.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/usart2/: usart2.c
  group Device
    ./Libraries/Device/Geehy/APM32F10x/Source/: startup_apm32f103xb.s system_apm32f10x.c
  group StdPeriphDriver
    ./Libraries/APM32F10x_StdPeriphDriver/src/: apm32f10x_gpio.c apm32f10x_rcm.c apm32f10x_usart.c apm32f10x_tmr.c apm32f10x_misc.c
